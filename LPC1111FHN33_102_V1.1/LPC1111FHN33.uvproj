# Keil uVision project LPC1111FHN33.uvproj, settings and files
target LPC1111FHN (ARM-ADS)
  device: LPC1111FHN33/102 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x2000) IRAM(0x10000000,0x0800) CPUTYPE("Cortex-M0") CLOCK(50000000) ELITTLE
  output: LPC1111FHN33 +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x800
  group Source Group
    ./: adc.c gpio.c main.c sys_cfg.c system_LPC11xx.c task.c timer.c uart.c watchdog.c startup_LPC11xx.s
